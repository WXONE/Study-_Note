TIME_COUNT0 DATA 30H
ORG 0000H
LJMP MAIN
ORG 000BH
LJMP ISTO
ORG 0100H

MAIN:
	MOV SP,#5FH
	MOV TIME_COUNT0,#40
	MOV TMOD,#01H
	MOV TL0,#0FFH
	MOV TH0,$4BH
	MOV TCON,#10H
	SETB ET0
	SETB EA
	AJMP $
ISTO:
	MOV TL0,#0FFH
	MOV TH0,#4BH

	DJNZ TIME_COUNT0,T0_INT_EXIT
	MOV TIME_COUNT0,#40
	CPL P0.0

TO_INT_EXIT:
RETI

END