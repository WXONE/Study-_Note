        ORG 0000H
		LJMP START
		ORG 0003H
		LJMP X0_INT
		ORG 0013H
		LJMP X1_INT
		ORG 0030H
START:
		SETB IT0
		SETB IT1
		SETB EX0
		SETB EX1
		SETB EA
		MOV SP,#50H
		MOV A,#00H

LOOP:	MOV P1,A
		SJMP LOOP

X0_INT:
		PUSH ACC
	   	PUSH PSW
		SETB RS0
		MOV A,#0FFH 
		MOV R2, #16

X0_1:
		MOV P1,A
		CALL DELAY
	    CPL A
		DJNZ R2,X0_1
		POP PSW
		POP ACC
		RETI

X1_INT:
		PUSH ACC
		PUSH PSW
		SETB RS1
		MOV A,#0FEH
		MOV R2,#16

X1_1:
		MOV P1,A
		CALL DELAY
		RL A
		DJNZ R2,X1_1
		POP PSW
		POP ACC
		RETI

DELAY:
	MOV R7,#17H
DL1:
    MOV R6,#98H
DL0:
    MOV R5,#46H
    DJNZ R5,$
    DJNZ R6,DL0
    DJNZ R7,DL1
    RET

END
